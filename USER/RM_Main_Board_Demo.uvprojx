# Keil uVision project RM_Main_Board_Demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\LINK_OUT\HAL_SDRAM;..\LINK_OUT\KEY;..\LINK_OUT\LED;..\HAL_LIB\Inc;..\CORE;..\LINK_OUT\HAL_LTDC;..\LINK_OUT\HAL_RGB_FONT;..\LINK_OUT\LCD;..\LINK_OUT\HAL_OLED_V2;..\LINK_OUT\FONT;..\LINK_OUT\TIM;..\LINK_OUT\OV7670;..\LINK_OUT\OV7670Configure;..\LINK_OUT\BMP;..\LINK_OUT\HA_USART_DMA;..\LINK_OUT\Position_Handle;..\LINK_OUT\HAL_GT911;..\LINK_OUT\BMP;..\LINK_OUT\HAL_24C02;..\LINK_OUT\DWM1000;..\LINK_OUT\decad;..\LINK_OUT\HAL_CAN;..\LINK_OUT\DBUS;..\LINK_OUT\MOTOR_Mecanum;..\LINK_OUT\ESC_POWER;..\LINK_OUT\PID
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f427xx.s
  group HAL_LIB
    ../HAL_LIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group LINK_OUT
    ../LINK_OUT/KEY/: KEY.c
    ../LINK_OUT/LED/: LED.c
    ../LINK_OUT/TIM/: TIM.c
    ../LINK_OUT/HA_USART_DMA/: HA_USART_DMA.c
    ../LINK_OUT/HAL_CAN/: CAN.c
    ../LINK_OUT/DBUS/: DBUS.c
    ../LINK_OUT/MOTOR_Mecanum/: MOTOR_Mecanum.c
    ../LINK_OUT/ESC_POWER/: ESC_POWER.c
    ../LINK_OUT/PID/: PID.c
